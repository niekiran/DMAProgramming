<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADC1_SRAM1_TEMP.ewp</path>
  </project>
  <batchBuild />
</workspace>
